# Keil uVision project C2.Flash.uvprojx, settings and files
target C2.Flash (ARM-ADS)
  device: EFM32ZG222F32 Energy Micro
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(24000000) ELITTLE
  output: C2.Flash.axf
  AfterMake: fromelf.exe --bin --output ..\..\C2.Flash.bin build\C2.Flash.axf
  c flags: Optim=4 OneElfS=1
  c define: EFM32ZG222F32
  c include: ..\;..\CMSIS\Include;..\EFM32ZG\Include;..\emlib\inc;..\kits\common\bsp;..\kits\common\drivers;..\kits\EFM32ZG_STK3200\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../EFM32ZG/Source/ARM/: startup_efm32zg.s
    ../EFM32ZG/Source/: system_efm32zg.c
  group drivers
    ../kits/common/bsp/: bsp_stk_leds.c
  group emlib
    ../emlib/src/: em_assert.c em_cmu.c em_gpio.c em_usart.c em_leuart.c em_system.c em_int.c em_emu.c
  group Source
    ../: C2.Flash.c
