# Keil uVision project C2-Flash.uvprojx, settings and files
target C2-Flash (ARM-ADS)
  device: EFM32GG990F1024 Energy Micro
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(48000000) ELITTLE
  output: C2-Flash
  c flags: Optim=1 OneElfS=1
  c define: EFM32GG990F1024
  c misc: --c99
  c include: ..\src;..\CMSIS\Include;..\Device\EnergyMicro\EFM32GG\Include;..\emlib\inc;..\usb\inc;..\kits\common\bsp;..\kits\EFM32GG_STK3700\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ../src/: main.c cdc.c usbio.c usbconfig.h
    ./: system_efm32gg.c startup_efm32gg.s
  group C2
    ../src/C2/: C2_Main.c C2_Utils.c C2_Flash.c Timing.c Errors.c Pins.c Devices.c Serial.c HEX_Utils.c
  group emlib
    ../emlib/src/: em_cmu.c em_gpio.c em_system.c em_emu.c em_timer.c em_int.c
  group emusb
    ../usb/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbdint.c em_usbhal.c em_usbtimer.c
  group bsp
    ../kits/common/bsp/: bsp_stk_leds.c
