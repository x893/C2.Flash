# Keil uVision project EC3.uvproj, settings and files
target EC3 (MCS-51)
  device: C8051F320 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(25000000)
  output: EC3 +hex
  c flags: Optimize=8 SizeSpeed=1
  asm include: .\
  group src
    ./: EC3.asm
