# Keil uVision project C2-Flash.uvprojx, settings and files
target C2.Flash.EFM32 (ARM-ADS)
  device: EFM32GG990F1024 Energy Micro
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(48000000) ELITTLE
  output: C2.Flash.EFM32.axf
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: EFM32GG990F1024
  c include: ..\src;..\CMSIS\Include;..\EFM32\;..\EFM32\Device\EnergyMicro\EFM32GG\Include;..\EFM32\emlib\inc;..\EFM32\usb\inc;..\EFM32\kits\common\bsp;..\EFM32\kits\EFM32GG_STK3700\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ../src/: C2_Main.c C2_Flash.c C2_Utils.c HEX_Utils.c Serial.c Devices.c Errors.c
  group efm32
    ../EFM32/: Platform.c Pins.c Timing.c cdc.c usbconfig.h usbio.c startup_efm32gg.s system_efm32gg.c
  group efm32/emlib
    ../EFM32/emlib/src/: em_cmu.c em_gpio.c em_system.c em_emu.c em_timer.c em_int.c
  group efm32/emusb
    ../EFM32/usb/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbdint.c em_usbhal.c em_usbtimer.c
  group efm32/bsp
    ../EFM32/kits/common/bsp/: bsp_stk_leds.c
  group stm32
    ../STM32/: startup_stm32f10x_md.s system_stm32f10x.c Platform.c Pins.c
  group stm32/lib
    ../STM32/StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
target C2.Flash.NUCLEO-103RB (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: C2.Flash.STM32.axf
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD
  c include: ..\src;..\CMSIS\Include;..\STM32\;..\STM32\StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
